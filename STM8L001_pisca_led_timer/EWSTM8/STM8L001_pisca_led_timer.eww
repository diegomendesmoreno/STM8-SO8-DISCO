<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM8L001_pisca_led_timer.ewp</path>
  </project>
  <batchBuild/>
</workspace>


