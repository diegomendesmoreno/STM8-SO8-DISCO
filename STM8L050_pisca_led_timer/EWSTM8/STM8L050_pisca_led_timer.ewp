# IAR project STM8L050_pisca_led_timer.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: EWSTM8_IAR
  ICCSTM8.CCIncludePath2: ..\STM8L15x_StdPeriph_Driver\inc; ..\User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8L050_pisca_led_timer.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group StdLib
    ../STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_tim2.c
  group User
    ../User/: main.c stm8l15x_it.c
